# IAR project Backup of SimpleAMP.ewp, settings and files
configuration SimpleAMP_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H755ZI_CM4 ST STM32H755ZI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H755xx; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; RPMSG_BUFFER_SIZE=512; VIRTIO_SLAVE_ONLY; NO_ATOMIC_64_SUPPORT
  ICCARM.CCIncludePath2: ../CM4/OPENAMP; ../CM4/Core/Inc; ../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../Middlewares/Third_Party/OpenAMP/libmetal/lib/include/metal/compiler/iar; ../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimpleAMP_CM4.hex
  ILINK.IlinkOutputFile: SimpleAMP_CM4.out
  ILINK.IlinkIcfFile: stm32h755xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SimpleAMP_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H755ZI_CM7 ST STM32H755ZI_CM7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H755xx; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; RPMSG_BUFFER_SIZE=512; VIRTIO_MASTER_ONLY; NO_ATOMIC_64_SUPPORT
  ICCARM.CCIncludePath2: ../CM7/OPENAMP; ../CM7/Core/Inc; ../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../Middlewares/Third_Party/OpenAMP/libmetal/lib/include/metal/compiler/iar; ../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: SimpleAMP_CM7.hex
  ILINK.IlinkOutputFile: SimpleAMP_CM7.out
  ILINK.IlinkIcfFile: stm32h755xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h755xx_CM4.s startup_stm32h755xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM4/OPENAMP
    ../CM4/OPENAMP/: mbox_hsem.c openamp.c rsc_table.c
  group Application/User/CM7/OPENAMP
    ../CM7/OPENAMP/: mbox_hsem.c openamp.c rsc_table.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/OpenAmp
    ../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
    ../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: condition.c generic_device.c generic_init.c generic_io.c generic_shmem.c time.c
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c CMakeLists.txt
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
    ../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
